# Keil uVision project UNIVERSKY.uvprojx, settings and files
target UNIVERSKY (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: UNIVERSKY
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ..\Control; ..\Log; ..\Math; ..\MAVLINK; ..\Messages; ..\Modules; ..\Navigation; ..\Sensors; ..\Tasks; ..\UavSystem; ..\Drivers\VL53L0X\inc
  asm include: ..\Inc;..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: main.c gpio.c adc.c freertos.c i2c.c spi.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group UavSystem
    ../UavSystem/: Board.c FaultDetect.c FlightStatus.c Parameter.c Board.h
  group Tasks
    ../Tasks/: ControlTask.c MessageQueue.c MessageTask.c ModuleTask.c NavigationTask.c SensorTask.c TaskConfig.h
  group Math
    ../Math/: Declination.c Kalman3.c LevenbergMarquardt.c LowPassFilter.c MathTool.c Matrix3.c Pid.c Quaternion.c Rotation.c Vector3.c
  group Navigation
    ../Navigation/: Ahrs.c AhrsAux.c Navigation.c
  group Control
    ../Control/: FlightControl.c MissionControl.c Motor.c Rc.c SafeControl.c UserControl.c WayPointControl.c
  group Messages
    ../Messages/: bsklink.c bsklinkDecode.c bsklinkSend.c MavlinkDecode.c MavlinkNotice.c MavlinkParam.c MavlinkSend.c Message.c
  group Sensors
    ../Sensors/: Accelerometer.c Barometer.c Gps.c Gyroscope.c Magnetometer.c Sensor.c Tof.c
  group Modules
    ../Modules/: Ak8975.c Battery.c Icm20689.c Module.c Spl06.c Ublox.c W25Qxx.c PwmIn.c ModulesConfig.h LedColors.c Vl53l0X.c
  group VL53L0X
    ../Drivers/VL53L0X/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_i2c.c vl53l0x_platform.c
software components: CMSIS:CORE 4.1.0

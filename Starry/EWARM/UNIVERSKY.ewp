# IAR project UNIVERSKY.ewp, settings and files
configuration UNIVERSKY (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; G:\Projects\Starry\Starry\Control; G:\Projects\Starry\Starry; G:\Projects\Starry\Starry\MAVLINK; G:\Projects\Starry\Starry\Messages; G:\Projects\Starry\Starry\Modules; G:\Projects\Starry\Starry\Navigation; G:\Projects\Starry\Starry\Sensors; G:\Projects\Starry\Starry\Sensors; G:\Projects\Starry\Starry\Tasks; G:\Projects\Starry\Starry\UavSystem; G:\Projects\Starry\Starry\Math
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: UNIVERSKY.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: adc.c freertos.c gpio.c main.c spi.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c stm32f4xx_it.c tim.c usart.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group Control
    ../Control/: FlightControl.c MissionControl.c Motor.c Rc.c SafeControl.c UserControl.c WayPointControl.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c
  group Math
    ../Math/: Declination.c Kalman3.c LevenbergMarquardt.c LowPassFilter.c MathTool.c Matrix3.c Pid.c Quaternion.c Rotation.c Vector3.c
  group Messages
    ../Messages/: bsklink.c bsklinkDecode.c bsklinkSend.c MavlinkDecode.c MavlinkNotice.c MavlinkParam.c MavlinkSend.c Message.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Modules
    ../Modules/: Ak8975.c Battery.c Icm20689.c Module.c PwmIn.c Spl06.c Ublox.c W25Qxx.c
  group Navigation
    ../Navigation/: Ahrs.c AhrsAux.c Navigation.c
  group Sensors
    ../Sensors/: Accelerometer.c Barometer.c Gps.c Gyroscope.c Magnetometer.c Sensor.c
  group Tasks
    ../Tasks/: ControlTask.c MessageQueue.c MessageTask.c ModuleTask.c NavigationTask.c SensorTask.c
  group UavSystem
    ../UavSystem/: Board.c FaultDetect.c FlightStatus.c Parameter.c
